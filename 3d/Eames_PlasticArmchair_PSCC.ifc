Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-01-31T16:32:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 31 16:32:46 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{258A3E86-EAE4-4CE1-A36B-4A7C5AFEBD29}\ifc * Database version: 5507 * Database creation date: Thu Jan 31 16:32:45 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 31 16:32:45 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 31 16:32:45 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Eames plastic side chair PSCC with seat cushion, CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_PSCC:Eames plastic side chair PSCC with seat cushion:318907
In: Level 1
Material: Plastic black, 03 aluminium polished, 01 chrome, Textile hopsak nero 66, 01 basic dark
Pset_ManufacturerTypeInformation - ModelReference: 44033600; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - HeightControl: 760 mm; OffsetControl: -5 mm; TotalHeight: 760 mm
Dimensions - Area: 1.6724 m2; Volume: 0.416176 m3
Materials and Finishes - ChairMainMaterial: 01 basic dark; ChairQuaternaryMaterial: Plastic black; ChairSecondaryMaterial: Textile hopsak nero 66
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_PSCC: Eames plastic side chair PSCC with seat cushion; Family and Type: CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_PSCC: Eames plastic side chair PSCC with seat cushion; InstallationDate: n/a; Material: Polypropylene, aluminium & textile; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_PSCC: Eames plastic side chair PSCC with seat cushion; Type Id: CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_PSCC: Eames plastic side chair PSCC with seat cushion; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
Construction(Type) - SeatCushionVisibility: yes; SeatType: Eames_plastic_PSCC_simplechair+cushion
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_PSCC; ConvergoRefNr: 0089-1812-0009-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office chairs; NBSReference: 45-35-20/330; ProductInformation: The varied selection of bases for the Plastic Chairs by Charles and Ray Eames makes it easy to find the right model for a wide range of locations and situations. For instance, the Pivot Side Chair Cast Base on Castors (PSCC) is ideal for home offices.; Revision: n/a; Uniclass2: Pr_40_50_12_57; Uniclass2015Description: Office chairs; Uniclass2015Reference: Pr_40_50_12_57; Version: 1; VersionDate: 21/01/2019
Identity Data(Type) - Collection: Eames plastic side chair; Cost: 0; Description: The varied selection of bases for the Plastic Chairs by Charles and Ray Eames makes it easy to find the right model for a wide range of locations and situations. For instance, the Pivot Side Chair Cast Base on Castors (PSCC) is ideal for home offices. Thanks to the organically shaped, swivel-mounted seat shell with shock-absorbing suspension and continuous height adjustment, the chair ensures superb comfort.; Designer: Charles & Ray Eames; Manufacturer: Vitra; Model: Eames plastic side chair PSCC with seat cushion; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/970265/storage/master/download/Factbook%20EPC-EN.pdf; Type Name: Eames plastic side chair PSCC with seat cushion; URL: https://www.vitra.com/en-un/living/product/details/eames-plastic-side-chair-pscc
Materials and Finishes(Type) - ChairQuinaryMaterial: 01 chrome; ChairTertiaryMaterial: 03 aluminium polished
Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_Eames_PlasticArmchair_PSCC; Features: Optional seat cushion or full upholstery. Height adjustable.; Finish: Seat shell: dyed-through polypropylene. All models are available with a seat cushion (screwed to the seat shell) or full upholstery. The fully upholstered version has moulded polyurethane foam padding covered in fabric, attached to the shell with a welted edge. Different shell and upholstery colours and various bases provide a multitude of possible combinations. Options: the Eames Plastic Chair is available as a visitor chair, dining chair, rocking chair, swivel chair or in stacking versions and with ganging brackets for row seating. Beam-mounted shells are suited for use in waiting areas. Base: five-star base in polished die-cast aluminium with double castors in basic dark. (PSCC = Pivot Side Chair Cast Base on Castors); Grade: n/a; ModelNumber: n/a; ModelReference: 44033600; Name: DmstcChrs_Eames_PlasticArmchair_PSCC_Cushion; ReplacementCost: n/a; Shape: Sculptured; Size: 740x740x760/885 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
